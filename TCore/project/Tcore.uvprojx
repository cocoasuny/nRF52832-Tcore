# Keil uVision project Tcore.uvprojx, settings and files
target nrf52832_xxaa (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD CONFIG_GPIO_AS_PINRESET FREERTOS NRF52 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74 NRF_SD_BLE_API_VERSION=4 S132 SOFTDEVICE_PRESENT
  c misc: --reduce_paths
  c include: ..\source\Application;..\source\Middlewares\freertos;..\source\SDK\drivers_nrf;..\source\Middlewares\freertos\config;..\source\Middlewares\freertos\portable\ARM;..\source\Middlewares\freertos\portable\CMSIS;..\source\Middlewares\freertos\source\include;..\source\SDK\softdevice\s132\headers;..\source\SDK\libraries\util;..\source\Middlewares\freertos\source\portable\MemMang;..\source\Middlewares\freertos\portable\ARM\nrf52;..\source\Middlewares\freertos\portable\CMSIS\nrf52;..\source\SDK\libraries\log;..\source\SDK\libraries\strerror;..\source\SDK\libraries\log\src;..\source\SDK\softdevice\common\softdevice_handler;..\source\SDK\drivers_nrf\hal;..\source\SDK\drivers_nrf\clock;..\source\SDK\drivers_nrf\common;..\source\SDK\libraries\fstorage;..\source\SDK\libraries\fstorage;..\source\SDK\libraries\experimental_section_vars;..\source\SDK\drivers_nrf\uart;..\source\SDK\drivers_nrf\power;..\source\BSP;..\source\SDK\libraries\cli;..\source\SDK\libraries\cli\uart;..\source\SDK\libraries\uart;..\source\SDK\libraries\fifo;..\source\SDK\ble;..\source\SDK\ble\nrf_ble_gatt;..\source\SDK\ble\ble_advertising;..\source\SDK\ble\ble_db_discovery;..\source\SDK\ble\common;..\source\SDK\libraries\timer;..\source\SDK\libraries\fds;..\source\SDK\ble\peer_manager;..\source\SDK\ble\ble_services\ble_hts;..\source\SDK\ble\ble_services\ble_bas;..\source\SDK\ble\ble_services\ble_dis
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FREERTOS NRF52 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74 NRF_SD_BLE_API_VERSION=4 S132 SOFTDEVICE_PRESENT
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFREERTOS,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=1024,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20001fc0 size 0xe040
  link misc: --diag_suppress 6330
  group Application
    ../source/Application/: main.c app_freertos.c measurement.c ble_top_implement.c FreeRTOSConfig.h sdk_config.h platform.h
  group BSP
    ../source/BSP/: bsp.c bsp_cli.c bsp_uart.c
  group BLEService/Periphral
    ../source/SDK/ble/ble_services/ble_hts/: ble_hts.c
    ../source/SDK/ble/ble_services/ble_bas/: ble_bas.c
    ../source/SDK/ble/ble_services/ble_dis/: ble_dis.c
  group Middleware/FreeRTOS
    ../source/Middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../source/Middlewares/freertos/source/portable/MemMang/: heap_1.c
    ../source/Middlewares/freertos/portable/ARM/nrf52/: port.c
    ../source/Middlewares/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group SDK/nRF_Drivers
    ../source/SDK/drivers_nrf/clock/: nrf_drv_clock.c
    ../source/SDK/drivers_nrf/common/: nrf_drv_common.c
    ../source/SDK/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../source/SDK/drivers_nrf/uart/: nrf_drv_uart.c
    ../source/SDK/drivers_nrf/power/: nrf_drv_power.c
    ../source/SDK/libraries/cli/: nrf_cli.c
    ../source/SDK/libraries/cli/uart/: nrf_cli_uart.c
  group SDKnRF_Libraries
    ../source/SDK/libraries/util/: app_error.c app_error_weak.c nrf_assert.c sdk_mapped_flags.c app_util_platform.c
    ../source/SDK/libraries/timer/: app_timer_freertos.c
    ../source/SDK/libraries/crc16/: crc16.c
    ../source/SDK/libraries/fds/: fds.c
    ../source/SDK/libraries/fstorage/: fstorage.c
    ../source/SDK/libraries/hardfault/: hardfault_implementation.c
    ../source/SDK/libraries/sensorsim/: sensorsim.c
    ../source/SDK/libraries/uart/: app_uart_fifo.c retarget.c
    ../source/SDK/libraries/fifo/: app_fifo.c
  group SDK/nRF_Log
    ../source/SDK/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group SDK/nRF_SoftDevice
    ../source/SDK/softdevice/common/softdevice_handler/: softdevice_handler.c
  group SDK/nRF_BLE
    ../source/SDK/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../source/SDK/ble/ble_advertising/: ble_advertising.c
    ../source/SDK/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../source/SDK/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.12.0
