# Keil uVision project secure_dfu_ble_s132.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74 NRF_DFU_DEBUG_VERSION NRF_DFU_SETTINGS_VERSION=1 NRF_SD_BLE_API_VERSION=4 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION SWI_DISABLE0 __HEAP_SIZE=0
  c misc: --reduce_paths
  c include: ..\source\Application;..\source\dfu_req_handling;..\source\MiddleWare\micro-ecc\nrf52_keil;..\source\MiddleWare\nano-pb\generator;..\source\MiddleWare\nano-pb;..\source\MiddleWare;..\source\SDK;..\source\SDK\ble;..\source\SDK\libraries\bootloader;..\source\SDK\libraries\bootloader\dfu;..\source\SDK\libraries\bootloader\ble_dfu;..\source\SDK\libraries\bootloader\serial_dfu;..\source\SDK\softdevice\common;..\source\SDK\softdevice\s132\headers;..\source\SDK\softdevice\s132\headers\nrf52;..\source\SDK\libraries\log;..\source\SDK\libraries\log\src;..\source\SDK\libraries\util;..\source\SDK\libraries\fstorage;..\source\SDK\libraries\strerror;..\source\SDK\libraries\experimental_section_vars;..\source\SDK\libraries\timer;..\source\SDK\ble\common;..\source\SDK\libraries\crc32;..\source\SDK\libraries\crypto;..\source\SDK\libraries\crypto\backend;..\source\SDK\libraries\crypto\backend\micro_ecc;..\source\SDK\drivers_nrf\hal;..\source\SDK\softdevice\common\softdevice_handler;..\source\SDK\drivers_nrf\delay;..\source\SDK\libraries\scheduler;..\source\SDK\drivers_nrf\common;..\source\SDK\libraries\queue;..\source\SDK\drivers_nrf\rng;..\source\SDK\libraries\crypto\backend\nrf_crypto_sw;..\source\SDK\libraries\mem_manager;..\source\SDK\libraries\sha256;..\source\MiddleWare\micro-ecc\micro-ecc;..\source\SDK\libraries\uart;..\source\SDK\libraries\uart;..\source\SDK\libraries\fifo;..\source\SDK\drivers_nrf\uart;..\source\BSP
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74,-DNRF_DFU_DEBUG_VERSION,-DNRF_DFU_SETTINGS_VERSION=1,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-DSWI_DISABLE0,-D__HEAP_SIZE=0
  asm include: ..\..\config\secure_dfu_ble_s132_pca10040_debug;..\..\config;..\..\..\..\..\components;..\..\..\..\..\components\ble\common;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\components\libraries\crypto\backend\nrf_crypto_sw;..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\components\libraries\hci;..\..\..\..\..\components\libraries\log;..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\components\libraries\queue;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\components\libraries\svc;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\components\toolchain;..\..;..\..\..\dfu_req_handling;..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\external\nano-pb;..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x73000 size 0xb000
  memory RVCT9: RAM 0x20002060 size 0xdf20
  link misc: --diag_suppress 6330
  group None
    ../source/dfu_req_handling/: dfu-cc.pb.c dfu_public_key.c dfu_req_handling.c
  group Application
    ../source/Application/: main.c sdk_config.h platform.h
  group BSP
    ../source/BSP/: bsp_uart.c
  group nRF_BLE
    ../source/SDK/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_BLE_DFU
    ../source/SDK/libraries/bootloader/ble_dfu/: nrf_ble_dfu.c
  group nRF_Bootloader
    ../source/SDK/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_asm.c nrf_bootloader_info.c
    ../source/SDK/libraries/bootloader/dfu/: nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c
  group nRF_Drivers
    ../source/SDK/drivers_nrf/common/: nrf_drv_common.c
    ../source/SDK/drivers_nrf/rng/: nrf_drv_rng.c
    ../source/SDK/drivers_nrf/hal/: nrf_nvmc.c
    ../source/SDK/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../source/SDK/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../source/SDK/libraries/scheduler/: app_scheduler.c
    ../source/SDK/libraries/timer/: app_timer.c
    ../source/SDK/libraries/crc32/: crc32.c
    ../source/SDK/libraries/fstorage/: fstorage.c
    ../source/SDK/libraries/hci/: hci_mem_pool.c
    ../source/SDK/libraries/mem_manager/: mem_manager.c
    ../source/SDK/libraries/queue/: nrf_queue.c
    ../source/SDK/libraries/strerror/: nrf_strerror.c
    ../source/SDK/libraries/sha256/: sha256.c
    ../source/SDK/libraries/uart/: app_uart_fifo.c retarget.c
    ../source/SDK/libraries/fifo/: app_fifo.c
  group nRF_Log
    ../source/SDK/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_SoftDevice
    ../source/SDK/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group nRF_crypto
    ../source/SDK/libraries/crypto/: nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_keys.c nrf_crypto_mem.c nrf_crypto_rng.c
  group nRF_crypto_backend
    ../source/SDK/libraries/crypto/backend/micro_ecc/: micro_ecc_lib_ecdh.c micro_ecc_lib_ecdsa.c micro_ecc_lib_init.c micro_ecc_lib_keys.c micro_ecc_lib_shared.c
    ../source/SDK/libraries/crypto/backend/nrf_crypto_sw/: nrf_crypto_sw_hash.c nrf_crypto_sw_rng.c
  group nRF_micro_ecc
    ../source/MiddleWare/micro-ecc/nrf52_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nano-pb
    ../source/MiddleWare/nano-pb/: pb_common.c pb_decode.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.12.0
